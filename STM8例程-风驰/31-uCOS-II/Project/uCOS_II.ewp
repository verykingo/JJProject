# IAR project uCOS_II.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S208R8 STM8S208R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\FWlib\inc; ..\FWlib\src; ..\USER; ..\uCOS-II\Source; ..\uCOS-II\Ports
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: uCOS_II.hex
  ILINK.IlinkOutputFile: uCOS_II.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group FWLib
    ../FWlib/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c
  group uCOS-II/Ports
    ../uCOS-II/Ports/: os_cpu_a.s os_cpu_c.c
  group uCOS-II/Source
    ../uCOS-II/Source/: ucos_ii.c
  group User
    ../USER/: app_hooks.c led.c main.c sysclock.c tim1.c
