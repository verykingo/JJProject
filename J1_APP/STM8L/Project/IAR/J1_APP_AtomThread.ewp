# IAR project J1_APP_AtomThread.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\User; ..\..\Driver\STM8L15x_StdPeriph_Driver\inc; ..\..\RTOS\atomthreads-1.3\kernel; ..\..\RTOS\atomthreads-1.3\ports
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: J1_APP_AtomThread.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Driver/STM8L15x_StdPeriph_Driver
    ../../Driver/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group RTOS/atomthreads-1.3/kernel
    ../../RTOS/atomthreads-1.3/kernel/: atomkernel.c atommutex.c atomqueue.c atomsem.c atomtimer.c
  group RTOS/atomthreads-1.3/ports
    ../../RTOS/atomthreads-1.3/ports/: atomport-asm-iar.s atomport-private.h atomport.c
  group User
    ../../User/: main.c stm8l15x_it.c sysclock.c vkleds.c vkqueue.c vksofttimer.c vktimetick.c
