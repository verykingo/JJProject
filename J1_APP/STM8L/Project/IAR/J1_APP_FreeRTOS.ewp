# IAR project J1_APP_FreeRTOS.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..\..\User; ..\..\Driver\STM8L15x_StdPeriph_Driver\inc; ..\..\RTOS\FreeRTOSv10.2.1\FreeRTOS\Source\include; ..\..\RTOS\FreeRTOSv10.2.1\FreeRTOS\Source\\portable\IAR\STM8
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Driver/STM8L15x_StdPeriph_Driver
    ../../Driver/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group RTOS/FreeRTOSv10.2.1/portable
    ../../RTOS/FreeRTOSv10.2.1/FreeRTOS/Source/portable/IAR/STM8/: port.c portasm.s
  group RTOS/FreeRTOSv10.2.1/source
    ../../RTOS/FreeRTOSv10.2.1/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group User
    ../../User/: main.c protocol.c softtimer.c stm8l15x_it.c sysclock.c timetick.c
